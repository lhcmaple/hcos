# Keil uVision project hcos.uvprojx, settings and files
target os (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: hcos
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group kernel
    ./kernel/: sched.c types.h etc.h
  group app
    ./app/: app.c
  group cpu
    ./cpu/: startup.s
